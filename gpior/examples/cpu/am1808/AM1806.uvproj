# Keil uVision project AM1806.uvproj, settings and files
target GPIOR (ARM-ADS)
  device: AM180X Texas Instruments
  cpu: CLOCK(60000000) CPUTYPE(ARM926EJ-S)
  output: AM1806
  c flags: Optim=1
  c define: am1808,MMU_INIT
  c include: .\include;.\include\yaffs;..\..\..\include;..\..\..\cpu;..\..\..\include\libs;..\..\..\include\cpu
  scatter file: .\AM1806.scatter
  group framework
    ./: JoyceSDK.lib
    ./include/: hex_ddrc.h hex_gpio.h hex_i2c.h hex_kbd.h hex_lcd.h hex_log.h hex_mcasp.h hex_mmc.h hex_mtd.h hex_nand.h hex_pllc.h hex_pwmc.h hex_spi.h hex_sysdelay.h hex_timer.h hex_uart.h hex_wdt.h mtd.h vfs.h
  group source
    ./: main.c
  group scatter
    ./: AM1806.scatter
