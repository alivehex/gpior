# Keil uVision project GPIOR.uvproj, settings and files
target AT91RM9200 (ARM-ADS)
  device: AT91RM9200 Atmel
  cpu: IRAM(0x00200000-0x00203FFF) IROM(0x00100000-0x0011FFFF) CLOCK(18430000) CPUTYPE(ARM920T)
  output: GPIOR
  c flags: Optim=1 oTime=1
  c include: ..\..\..\..\include;..\..\..\..\include\cpu;..\..\..\..\include\libs;..\..\at91rm9200;..\..\..\..\cpu
  memory RVCT4: ROM 0x100000 size 0x20000
  memory RVCT9: RAM 0x200000 size 0x4000
  scatter file: .\scat.scatter
  link misc: --entry=VCT_TABLE
  group startup
    ../: cstartup.c startup.s
  group source
    ./: main.c
  group docs
    ./: at91rm9200.ini scat.scatter
  group asm
    ../: delay.s
  group libs
    ../../../../libs/: crc7.c crc16.c trace.c
