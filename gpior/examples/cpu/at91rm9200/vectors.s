	PRESERVE8
	AREA VECT, CODE, READONLY	
	ENTRY
	ARM
	
	; for REMAP thing
	EXPORT VCT_TABLE	
	IMPORT RESET_HANDLER

	; vector table
VCT_TABLE	
	LDR PC, RESET_ADDR
	LDR PC, UNDEF_ADDR
	LDR PC, SWI_ADDR
	LDR PC, PREFETCH_ADDR
	LDR PC, ABORT_ADDR
	NOP
	LDR PC, IRQ_ADDR
	LDR PC, FIQ_ADDR
		
RESET_ADDR 		DCD 	RESET_HANDLER
UNDEF_ADDR		DCD 	UNDEF_HANDLER
SWI_ADDR		DCD 	SWI_HANDLER
PREFETCH_ADDR	DCD 	PREFETCH_HANDLER
ABORT_ADDR		DCD 	ABORT_HANDLER
IRQ_ADDR		DCD 	IRQ_HANDLER
FIQ_ADDR		DCD 	FIQ_HANDLER	

	; dummy handlers
UNDEF_HANDLER		B 	UNDEF_HANDLER
SWI_HANDLER			B	SWI_HANDLER	
PREFETCH_HANDLER	B	PREFETCH_HANDLER
ABORT_HANDLER		B	ABORT_HANDLER
IRQ_HANDLER			B	IRQ_HANDLER
FIQ_HANDLER			B	FIQ_HANDLER	
		
	END