# Keil uVision project at91sam3u.uvproj, settings and files
target sam3u2c (ARM-ADS)
  device: SAM3U2C Atmel
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x00080000-0x0009FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: at91sam3u
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: TRACE_LEVEL=0,NOFPUT
  c misc: --gnu
  c include: ..\fatfs;..\startup;..\drivers;..\memories;..\peripherals;..\..\sam3u2c
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20080000 size 0x4000
  scatter file: .\flash.sct
  group startup
    ../startup/: board_cstartup_keil.c board_lowlevel.c board_memories.c exceptions.c
  group peripherals
    ../peripherals/pio/: pio.c
    ../peripherals/dbgu/: dbgu.c
    ../peripherals/pmc/: pmc.c
    ../peripherals/irq/: nvic.c
    ../peripherals/systick/: systick.c
    ../peripherals/dma/: dma.c
    ../peripherals/hsmc4/: hsmc4.c
    ../peripherals/mci/: mci_hs.c
    ../peripherals/rtc/: rtc.c
    ../peripherals/rtt/: rtt.c
    ../peripherals/spi/: spi.c
    ../peripherals/ssc/: ssc.c
    ../peripherals/twi/: twi.c
    ../peripherals/eefc/: eefc.c
  group source
    ./: main.c
    ../utility/: retarget.c
  group scatter
    ./Listings/: at91sam3u.map
    ./: flash.sct
  group drivers
    ../drivers/dmad/: dmad.c
    ../memories/: Media.c MEDSdcard.c
    ../memories/sdmmc/: sdmmc_mci.c
  group utility
    ../utility/: math.c dfm_fatfs.c
  group fatfs
    ../fatfs/: diskio.c ff.c
